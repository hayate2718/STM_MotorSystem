# Repository hayate2718/STM_MotorSystem

File README.md:

# STM_MotorSystem
モーターシステム<br>
MCU_bord_subは半導体不足でMCP2562のSOIC8pinパッケージがなかったとき用<br>
VL逆接したら多分壊れるので気を付けてね。ダイオードつけるの忘れてたてへぺろリン<br>
ファームウェアなどプログラム関係は[STM_MotorSystem_Programのwiki](https://github.com/hayate2718/STM_MotorSystem_Program/wiki)を参照

|ピン|ペリフェラル|用途|
|---|---|---|
|PA0|TIM2(エンコーダモード)|直行エンコーダB相|
|PA1|TIM2(エンコーダモード)|直行エンコーダA相|
|PA2|GPIO(INPUT)|FF1|
|PA3|GPIO(INPUT)|FF2|
|PA5|ADC2|電流センサ出力|
|PA7|GPIO(OUTPUT)|RESET|
|PB0|TIM3(PWM)|モータ制御用PWM|
|PB1|GPIO(INPUT)|基板アドレス用ID1bit|
|PA8|GPIO(INPUT)|基板アドレス用ID2bit|
|PA9|GPIO(INPUT)|基板アドレス用ID3bit|
|PA10|GPIO(INPUT)|基板アドレス用ID4bit|
|PA11|CAN_RX|CAN_RX|
|PA12|CAN_TX|CAN_TX|
|PB4|GPIO(OUTPUT)|DIR|
|PB5|GPIO(OUTPUT)|COAST|

## 結局スナバ回路つけなかった

## EAGLE design FET_bord/FET_bord.brd

Parts:
C1, C5, C6, C11, C12, C13, C14: 0.1u; C1608
C7, C18: 1u; C1608
C8, C9: 0.22u; C1608
C10: 10u; C1608
C15: 4.7u; C1608
C16, C19: 2.2u; C1608
C17: 100u; C3216
CON1, CON2: JQ_P8P
CPOL1, CPOL2, CPOL3: 330u; 1014CAPA
IC1: ADP151AUJZ; SOT23-5
IC2: NJW1616T; SOT23-6
IC_1: TLP291
IC_2: TLP290-4; TLP290
IC_3: TLP152; SO6-5
L1: 22u; SMD_INDUCTOR
R1: 0; 1608
R2, R3, R4, R5: 1k; 1608
R6: 2.4k; 1608
R7: 20k; 1608
R8: 33k; 1608
R9, R10, R11, R12, R13, R14, R22: 10k; 1608
R15, R16, R17, R18: 10; 1608
R20: 3.3k; 1608
R21: 2k; 1608
R_I1, R_I2: 1k; 0603X4RESISTOR
R_I3, R_I4: 10k; 1005X4RESISTOR
TR1, TR2, TR3, TR4: SKI03021; D2PACK
U$1: VL_4P
U$2: A3921; TSSOP_28P_ALLEGRO
U$3: ACS711; SOIC8
U$4: ss2040; SOD_123
U$5, U$7: FDC6305; SSOT6
U$6: RGB_LED
U$8: BOX10PBOX10P-L; BOX10P-L
U$9, U$10, U$11, U$12: SBR15U30SP5; POWERDI_5
U$13: HS38382; 38X38SQ

Connections:
5V: C15.1, CON1.P$5 (PIN5), IC1.1 (1_VIN), IC1.3 (3_EN), U$8.P$9, U$8.P$10
12V: C19.1, IC2.5 (5_VIN), R22.2, U$8.P$1, U$8.P$2
+3V3: C17.1, C18.1, CON1.P$6 (PIN6), L1.P$2 (2), R9.2, R10.2, R20.2
CAN_N: CON2.P$8 (PIN8), U$8.P$6
CAN_P: CON2.P$7 (PIN7), U$8.P$5
COAST: IC_2.2_C, R_I3.3, U$2.PIN21 (PIN21_SR), U$2.PIN22 (PIN22_PWML)
COAST_IN: CON1.P$3 (PIN3), R5.1
DIR: IC_2.1_C, R_I3.4, U$2.PIN19 (PIN19_PHASE)
DIR_IN: CON1.P$4 (PIN4), R4.1
FF1: R_I4.3, U$2.PIN25 (PIN25_FF1), U$5.1 (PIN1_G1), U$7.1 (PIN1_G1)
FF1O: IC_2.3_K, R_I2.5
FF1_IN: CON1.P$2 (PIN2), IC_2.3_C, R9.1
FF2: R_I4.2, U$2.PIN26 (PIN26_FF2), U$5.3 (PIN3_G2), U$7.3 (PIN3_G2)
FF2O: IC_2.4_K, R_I2.8
FF2_IN: CON1.P$1 (PIN1), IC_2.4_C, R10.1
GHA: R18.1, U$2.PIN10 (PIN10_GHA)
GHB: R15.1, U$2.PIN5 (PIN5_GHB)
GLA: R17.1, U$2.PIN12 (PIN12_GLA)
GLB: R16.1, U$2.PIN3 (PIN3_GLB)
GND: C11.2, C12.2, C13.2, CPOL1.-, CPOL2.-, CPOL3.-, R1.2, R12.1, R13.1, TR3.3 (PIN3_S), TR4.3 (PIN3_S), U$1.P$1 (PIN1), U$2.PIN2 (PIN2_LSS), U$10.1 (A1), U$10.2 (A2), U$11.1 (A1), U$11.2 (A2)
GNDI: C1.2, C5.2, C6.2, C10.1, IC_1.PIN3 (3_E), IC_2.1_E, IC_2.2_E, IC_3.4 (GND), R1.1, R6.2, R7.2, R_I3.8, R_I4.8, U$2.PAD, U$2.PIN17 (PIN17_GND), U$5.2 (PIN2_S2), U$5.5 (PIN5_S1), U$6.B_K, U$7.2 (PIN2_S2), U$7.5 (PIN5_S1)
GNDINT: C14.1, C15.2, C16.2, C17.2, C19.2, CON1.P$7 (PIN7), CON1.P$8 (PIN8), CON2.P$1 (PIN1), CON2.P$3 (PIN3), IC1.2 (2_GND), IC2.2 (2_GND), IC_1.PIN2 (2_K), IC_2.1_K, IC_2.2_K, IC_2.3_E, IC_2.4_E, IC_3.3 (K), R21.1, U$3.P$5 (5_GND), U$4.A, U$8.P$7, U$8.P$8
M: U$1.P$2 (PIN2), U$3.P$3 (3_IP-), U$3.P$4 (4_IP-)
unnamed: U$5.6 (PIN6_D1), U$6.G_K
unnamed: IC2.6 (6_SW), L1.P$1 (1), U$4.K (C)
unnamed: R_I2.1, U$7.4 (PIN4_D2)
unnamed: U$5.4 (PIN4_D2), U$6.R_K
unnamed: R_I1.1, U$6.B_A
unnamed: R_I1.2, U$6.G_A
unnamed: R_I1.3, U$6.R_A
unnamed: R_I2.4, U$7.6 (PIN6_D1)
unnamed: IC_3.1 (A), R2.2
unnamed: IC_1.PIN1 (1_A), R3.2
unnamed: IC_2.1_A, R4.2
unnamed: IC_2.2_A, R5.2
unnamed: C7.1, U$2.PIN16 (PIN16_CP1)
unnamed: C7.2, U$2.PIN15 (PIN15_CP2)
unnamed: C8.2, U$2.PIN9 (PIN9_CA)
unnamed: C9.2, U$2.PIN6 (PIN6_CB)
unnamed: C10.2, U$2.PIN8 (PIN8_VREG)
unnamed: C18.2, IC2.3 (3_FB), R20.1, R21.2
unnamed: R13.2, R17.2, TR4.1 (PIN1_G)
unnamed: R14.2, R18.2, TR2.1 (PIN1_G)
unnamed: R11.2, R15.2, TR1.1 (PIN1_G)
unnamed: R12.2, R16.2, TR3.1 (PIN1_G)
unnamed: IC2.4 (4_SHDN), R22.1
PWM: IC_3.5 (OUT), R_I3.1, U$2.PIN23 (PIN23_PWMH)
PWM_IN: CON2.P$5 (PIN5), R2.1
RDEAD: R7.1, R_I4.1, U$2.PIN27 (PIN27_RDEAD)
RESET: IC_1.PIN4 (4_C), R8.1, U$2.PIN24 (PIN24_RESET)
RESET_IN: CON2.P$6 (PIN6), R3.1
SA: C8.1, R14.1, TR2.3 (PIN3_S), TR4.2 (PIN2_D), U$2.PIN11 (PIN11_SA), U$3.P$1 (1_IP+), U$3.P$2 (2_IP+), U$11.3 (K), U$12.1 (A1), U$12.2 (A2)
SB: C9.1, R11.1, TR1.3 (PIN3_S), TR3.2 (PIN2_D), U$1.P$3 (PIN3), U$2.PIN4 (PIN4_SB), U$9.1 (A1), U$9.2 (A2), U$10.3 (K)
SENS_VCC: C14.2, C16.1, CON2.P$4 (PIN4), IC1.5 (5_VOUT), U$3.P$8 (8_VCC)
V5: C5.1, C6.1, IC_2.3_A, IC_2.4_A, IC_3.6 (VCC), R_I1.6, R_I1.7, R_I1.8, R_I3.5, R_I3.6, R_I4.5, R_I4.6, R_I4.7, U$2.PIN20 (PIN20_V5)
VDD: C1.1, C11.1, C12.1, C13.1, CPOL1.+, CPOL2.+, CPOL3.+, R8.2, TR1.2 (PIN2_D), TR2.2 (PIN2_D), U$1.P$4 (PIN4), U$2.PIN1 (PIN1_VDRAIN), U$2.PIN13 (PIN13_VBB), U$9.3 (K), U$12.3 (K)
VDSTH: R6.1, R_I4.4, U$2.PIN28 (PIN28_VDSTH)
VIOUT: CON2.P$2 (PIN2), U$3.P$7 (7_VIOUT)

Notes on the sheet:
deadtime = 280ns
電解コンデンサには秋月のP-14450を用いる
CAN_P = CAN_H CAN_N = CAN_L

Board: 2 copper layers, 85.0 x 54.0 mm, 69 parts (43 on the bottom side), 58 nets.

## EAGLE design MCU_bord_sub/MCU_bord.brd

Parts:
C1, C4, C8: 0.1u; C1608
C2, C3, C7: 10u; C1608
C5: 4.7u; C1608
C6: 1u; C1608
CON1, CON2: JQ_S8P
CON3: XH_5P
IC1: MCP2562; DIL8
LED1: 1608LED; 1608
OSC1: 12M; CSTNE#
R1: 120; 1608
R2: 10k; 1608
R3: 1k; 1608
R_I1: R_SHUGOU2; 1005X4RESISTOR
SW1: DIPSW4
U$1: STM32F303K_32LQFP; LQFP32-7X7
U$2: TAKUTOSUITTI2
U$3: BOX14P; CON_HEDA14P_1.27

Connections:
+3V3: C2.1, C4.2, C5.1, CON1.P$6 (PIN6), IC1.PIN5 (VIO), R3.1, SW1.P$5 (5), SW1.P$6 (6), SW1.P$7 (7), SW1.P$8 (8), U$1.1 (PIN1_VDD), U$1.17 (PIN17_VDD), U$3.3
+5V: C1.1, C3.1, CON1.P$5 (PIN5), CON3.P$2 (PIN2), IC1.PIN3 (VDD)
A_CH: CON3.P$3 (PIN3), U$1.7 (PIN7)
B_CH: CON3.P$1 (PIN1), U$1.6 (PIN6)
CAN_N: CON2.P$8 (PIN8), IC1.PIN6 (CANL), R1.1
CAN_P: CON2.P$7 (PIN7), IC1.PIN7 (CANH), R1.2
CAN_RX: IC1.PIN4 (RXD), U$1.21 (PIN21)
CAN_TX: IC1.PIN1 (TXD), U$1.22 (PIN22)
COAST: CON1.P$3 (PIN3), U$1.28 (PIN28)
DIR: CON1.P$4 (PIN4), U$1.27 (PIN27)
FF1: CON1.P$2 (PIN2), U$1.8 (PIN8)
FF2: CON1.P$1 (PIN1), U$1.9 (PIN9)
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, CON1.P$7 (PIN7), CON1.P$8 (PIN8), CON2.P$1 (PIN1), CON2.P$3 (PIN3), CON3.P$5 (PIN5), IC1.PIN2 (VSS), IC1.PIN8 (STBY), LED1.K, OSC1.P$2 (GND), R2.2, R_I1.1, R_I1.2, R_I1.3, R_I1.4, U$1.16 (PIN16_VSS), U$1.32 (PIN32_VSS), U$2.P$1 (PIN1), U$3.5, U$3.7, U$3.11
ID1: R_I1.8, SW1.P$1 (1), U$1.15 (PIN15)
ID2: R_I1.7, SW1.P$2 (2), U$1.18 (PIN18)
ID3: R_I1.6, SW1.P$3 (3), U$1.19 (PIN19)
ID4: R_I1.5, SW1.P$4 (4), U$1.20 (PIN20)
unnamed: OSC1.P$1 (IN), U$1.3 (PIN3_OSCOUT)
unnamed: OSC1.P$3 (OUT), U$1.2 (PIN2_OSCIN)
unnamed: R2.1, U$1.31 (PIN31_BOOT0)
unnamed: LED1.A, R3.2
NRST: C8.1, U$1.4 (PIN4_NRST), U$2.P$2 (PIN2), U$3.12
PWM: CON2.P$5 (PIN5), U$1.14 (PIN14)
RESET: CON2.P$6 (PIN6), U$1.13 (PIN13)
T_JCLK/SWCLK: U$1.24 (PIN24), U$3.6
T_JTDI: U$1.25 (PIN25), U$3.10
T_JTDO/SWO: U$1.26 (PIN26), U$3.8
T_JTMS/SWDIO: U$1.23 (PIN23), U$3.4
T_VCP_RX: U$1.30 (PIN30), U$3.13
T_VCP_TX: U$1.29 (PIN29), U$3.14
VDDA: C6.1, C7.1, CON2.P$4 (PIN4), U$1.5 (PIN5_VDDA)
VIOUT: CON2.P$2 (PIN2), U$1.11 (PIN11)

Notes on the sheet:
電源確認用色指定なし

Board: 2 copper layers, 32.0 x 54.0 mm, 22 parts (7 on the bottom side), 32 nets.

## EAGLE design ALL_bord.brd

Board: 2 copper layers, 88.5 x 85.0 mm, 89 parts (53 on the bottom side), 90 nets.

Parts:
C1, C4, C8, C9, C10, C15, C16, C17, C18, C24: 0.1u; C1608
C2, C3, C7, C14: 10u; C1608
C5, C19: 4.7u; C1608
C6, C11, C22: 1u; C1608
C12, C13: 0.22u; C1608
C20, C23: 2.2u; C1608
C21: 100u; C3216
CON1, CON2: JQ_S8P
CON3, CON4: JQ_P8P
CPOL1, CPOL2, CPOL3: 330u; 1014CAPA
IC1: SOIC8
IC2: SOT23-5
IC3: SOT23-6
IC_1: TLP291
IC_2: TLP290
IC_3: SO6-5
L1: 22u; SMD_INDUCTOR
OSC1: 12M; CSTNE#
R1, R2, R9, R10, R11, R12, R13, R14, R22: 10k; 1608
R3: 0; 1608
R4, R5, R19, R23: 1k; 1608
R6: 2.4k; 1608
R7: 20k; 1608
R8: 33k; 1608
R15, R16, R17, R18: 10; 1608
R20: 3.3k; 1608
R21: 2k; 1608
R_I1: 1005X4RESISTOR
R_I2, R_I3: 0603X4RESISTOR
R_I4, R_I5: 10k; 1005X4RESISTOR
SW1: DIPSW4
TR1, TR2, TR3, TR4: D2PACK
U$1: STM32F303K_32LQFP; LQFP32-7X7
U$2: TAKUTOSUITTI2
U$3: BOX14P; CON_HEDA14P_1.27
U$4: ZH_5P
U$5: ACS711; SOIC8
U$6: VL_4P
U$7: A3921; TSSOP_28P_ALLEGRO
U$8, U$10: FDC6305; SSOT6
U$9: RGB_LED
U$11: BOX10PBOX10P-L; BOX10P-L
U$12: ss2040; SOD_123
U$13: HS38382; 38X38SQ
U$14, U$15, U$16, U$17: SBR15U30SP5; POWERDI_5

Connections:
5V: C19.1, CON3.P$5, IC2.1, IC2.3, U$11.P$9, U$11.P$10
12V: C23.1, IC3.5, R22.2, U$11.P$1, U$11.P$2
+3V1: C21.1, C22.1, CON3.P$6, L1.P$2, R9.2, R10.2, R20.2
+3V3: C2.1, C4.2, C5.1, CON1.P$6, IC1.P$5, R_I1.5, R_I1.6, R_I1.7, R_I1.8, U$1.1, U$1.17, U$3.3
+5V: C1.1, C3.1, CON1.P$5, IC1.P$3, R1.1, U$4.PIN2
A_CH: U$1.7, U$4.PIN3
B_CH: U$1.6, U$4.PIN1
CAN_N: CON2.P$8, IC1.P$6
CAN_N1: CON4.P$8, U$11.P$6
CAN_P: CON2.P$7, IC1.P$7
CAN_P1: CON4.P$7, U$11.P$5
CAN_RX: IC1.P$4, U$1.21
CAN_TX: IC1.P$1, U$1.22
COAST: CON1.P$3, U$1.28
COAST1: IC_2.2_C, R_I4.3, U$7.PIN21, U$7.PIN22
COAST_IN: CON3.P$3, R23.1
DIR: CON1.P$4, U$1.27
DIR1: IC_2.1_C, R_I4.4, U$7.PIN19
DIR_IN: CON3.P$4, R19.1
FF1: CON1.P$2, U$1.8
FF1O: IC_2.3_K, R_I3.5
FF1_IN: CON3.P$2, IC_2.3_C, R9.1
FF2: CON1.P$1, U$1.9
FF2O: IC_2.4_K, R_I3.8
FF2_IN: CON3.P$1, IC_2.4_C, R10.1
FF3: R_I5.2, U$7.PIN26, U$8.3, U$10.3
FF4: R_I5.3, U$7.PIN25, U$8.1, U$10.1
GHA: R18.1, U$7.PIN10
GHB: R15.1, U$7.PIN5
GLA: R17.1, U$7.PIN12
GLB: R16.1, U$7.PIN3
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, CON1.P$7, CON1.P$8, CON2.P$1, CON2.P$3, IC1.P$2, OSC1.P$2, R2.2, SW1.P$1, SW1.P$2, SW1.P$3, SW1.P$4, U$1.16, U$1.32, U$2.P$1, U$3.5, U$3.7, U$3.11, U$4.PIN5
GND1: C15.2, C16.2, C17.2, CPOL1.-, CPOL2.-, CPOL3.-, R3.2, R12.1, R13.1, TR3.3, TR4.3, U$6.P$1, U$7.PIN2, U$15.1, U$15.2, U$16.1, U$16.2
GNDI: C9.2, C10.2, C14.1, C24.2, IC_1.PIN3, IC_2.1_E, IC_2.2_E, IC_3.4, R3.1, R6.2, R7.2, R_I4.8, R_I5.8, U$7.PAD, U$7.PIN17, U$8.2, U$8.5, U$9.B_K, U$10.2, U$10.5
GNDINT: C18.1, C19.2, C20.2, C21.2, C23.2, CON3.P$7, CON3.P$8, CON4.P$1, CON4.P$3, IC2.2, IC3.2, IC_1.PIN2, IC_2.1_K, IC_2.2_K, IC_2.3_E, IC_2.4_E, IC_3.3, R21.1, U$5.P$5, U$11.P$7, U$11.P$8, U$12.A
ID1: R_I1.1, SW1.P$8, U$1.15
ID2: R_I1.2, SW1.P$7, U$1.18
ID3: R_I1.3, SW1.P$6, U$1.19
ID4: R_I1.4, SW1.P$5, U$1.20
M: U$5.P$3, U$5.P$4, U$6.P$2
unnamed: OSC1.P$1, U$1.3
unnamed: OSC1.P$3, U$1.2
unnamed: R2.1, U$1.31
unnamed: U$8.6, U$9.G_K
unnamed: U$8.4, U$9.R_K
unnamed: IC3.6, L1.P$1, U$12.K
unnamed: IC1.P$8, R1.2
unnamed: R_I2.1, U$9.B_A
unnamed: R_I2.2, U$9.G_A
unnamed: R_I2.3, U$9.R_A
unnamed: R_I3.1, U$10.4
unnamed: R_I3.4, U$10.6
unnamed: IC_3.1, R4.2
unnamed: IC_1.PIN1, R5.2
unnamed: IC_2.1_A, R19.2
unnamed: IC_2.2_A, R23.2
unnamed: C11.1, U$7.PIN16
unnamed: C11.2, U$7.PIN15
unnamed: C12.2, U$7.PIN9
unnamed: C13.2, U$7.PIN6
unnamed: C14.2, U$7.PIN8
unnamed: C22.2, IC3.3, R20.1, R21.2
unnamed: R13.2, R17.2, TR4.1
unnamed: R14.2, R18.2, TR2.1
unnamed: R11.2, R15.2, TR1.1
unnamed: R12.2, R16.2, TR3.1
unnamed: IC3.4, R22.1
NRST: C8.1, U$1.4, U$2.P$2, U$3.12
PWM: CON2.P$5, U$1.14
PWM1: IC_3.5, R_I4.1, U$7.PIN23
PWM_IN: CON4.P$5, R4.1
RDEAD: R7.1, R_I5.1, U$7.PIN27
RESET: CON2.P$6, U$1.13
RESET1: IC_1.PIN4, R8.1, U$7.PIN24
RESET_IN: CON4.P$6, R5.1
SA: C12.1, R14.1, TR2.3, TR4.2, U$5.P$1, U$5.P$2, U$7.PIN11, U$16.3, U$17.1, U$17.2
SB: C13.1, R11.1, TR1.3, TR3.2, U$6.P$3, U$7.PIN4, U$14.1, U$14.2, U$15.3
SENS_VCC: C18.2, C20.1, CON4.P$4, IC2.5, U$5.P$8
T_JCLK/SWCLK: U$1.24, U$3.6
T_JTDI: U$1.25, U$3.10
T_JTDO/SWO: U$1.26, U$3.8
T_JTMS/SWDIO: U$1.23, U$3.4
T_VCP_RX: U$1.30, U$3.13
T_VCP_TX: U$1.29, U$3.14
V5: C9.1, C10.1, IC_2.3_A, IC_2.4_A, IC_3.6, R8.2, R_I2.6, R_I2.7, R_I2.8, R_I4.5, R_I4.6, R_I5.5, R_I5.6, R_I5.7, U$7.PIN20
VDD: C15.1, C16.1, C17.1, C24.1, CPOL1.+, CPOL2.+, CPOL3.+, TR1.2, TR2.2, U$6.P$4, U$7.PIN1, U$7.PIN13, U$14.3, U$17.3
VDDA: C6.1, C7.1, CON2.P$4, U$1.5
VDSTH: R6.1, R_I5.4, U$7.PIN28
VIOUT: CON2.P$2, U$1.11
VIOUT1: CON4.P$2, U$5.P$7

## Commit log

2021-08-23 add file
2021-08-23 add ignore
2021-08-27 スナバ回路資料追加
2021-08-27 記号修正
2021-08-27 スナバ追加
2021-08-28 a3921ロジック回路周りの設計
2021-08-30 ロジック部を設計
2021-08-31 回路図ほぼ完成
2021-08-31 基板設計を開始した
2021-09-01 スナバ消した。基盤が結構仕上がってきた
2021-09-01 基板設計ほぼ終わりあとは仕上げ
2021-09-02 設計終了、DRC通った。がばでたを出力した
2021-09-04 mcu側に着手
2021-09-05 mcu側回路図多分完成。基板側に着手する予定
2021-09-05 MCU側完成。文字の位置とかの調整をやれば発注できる
2021-09-05 TIMピンの選択ミスったのなおした
2021-09-05 ミス直し
2021-09-13 端子名を記入
2021-09-14 発注用データ
2021-09-14 がばでた
2021-10-26 基板エラー修正
2021-10-28 canトランシーバ終端抵抗追加、電源確認用LED追加
2021-10-29 DIL8PINverのMCP2562搭載MCUボード追加
2021-11-06 集合抵抗value記入
2021-11-06 ぱあつりすとついか
